<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>ECTproject</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <group>
      <name>EWARM</name>
      <file>
        <name>$PROJ_DIR$\startup_stm32f100xb.s</name>
      </file>
    </group>
    <group>
      <name>User</name>
      <group>
        <name>Core</name>
        <file>
          <name>$PROJ_DIR$\..\Core\Src\main.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Core\Inc\main.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Core\Src\stm32f1xx_hal_msp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Core\Src\stm32f1xx_it.c</name>
        </file>
      </group>
      <group>
        <name>Module</name>
        <group>
          <name>BTC</name>
          <file>
            <name>$PROJ_DIR$\..\Module\BTC\drv_src\btc_drv.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\BTC\drv_src\btc_drv.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\BTC\c_src\btc_glb_vars.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\BTC\c_src\btc_glb_vars.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\BTC\c_src\btc_idef.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\BTC\c_src\btc_init.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\BTC\c_src\btc_init.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\BTC\c_src\btc_task.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\BTC\c_src\btc_task.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\BTC\btc_udef.h</name>
          </file>
        </group>
        <group>
          <name>CRC</name>
          <file>
            <name>$PROJ_DIR$\..\Module\CRC\drv_src\crc_drv.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\CRC\drv_src\crc_drv.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\CRC\c_src\crc_glb_vars.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\CRC\c_src\crc_glb_vars.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\CRC\c_src\crc_idef.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\CRC\c_src\crc_init.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\CRC\c_src\crc_init.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\CRC\c_src\crc_task.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\CRC\c_src\crc_task.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\CRC\crc_udef.h</name>
          </file>
        </group>
        <group>
          <name>FK</name>
          <file>
            <name>$PROJ_DIR$\..\Module\FK\fk_adc_udef.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\FK\fk_dac_udef.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\FK\fk_dma_udef.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\FK\drv_src\fk_drv.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\FK\drv_src\fk_drv.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\FK\fk_flash_udef.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\FK\c_src\fk_glb_vars.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\FK\c_src\fk_glb_vars.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\FK\fk_gpio_udef.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\FK\fk_i2c_udef.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\FK\c_src\fk_idef.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\FK\c_src\fk_init.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\FK\c_src\fk_init.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\FK\fk_nvic_udef.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\FK\fk_power_udef.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\FK\fk_rtc_udef.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\FK\fk_spi_udef.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\FK\fk_system_udef.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\FK\c_src\fk_task.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\FK\c_src\fk_task.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\FK\fk_timer_udef.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\FK\fk_uart_udef.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\FK\fk_udef.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\FK\fk_watch_dog_udef.h</name>
          </file>
        </group>
        <group>
          <name>HBTC</name>
          <file>
            <name>$PROJ_DIR$\..\Module\HBTC\drv_src\hbtc_drv.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\HBTC\drv_src\hbtc_drv.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\HBTC\c_src\hbtc_glb_vars.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\HBTC\c_src\hbtc_glb_vars.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\HBTC\c_src\hbtc_idef.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\HBTC\c_src\hbtc_init.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\HBTC\c_src\hbtc_init.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\HBTC\c_src\hbtc_task.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\HBTC\c_src\hbtc_task.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\HBTC\hbtc_udef.h</name>
          </file>
        </group>
        <group>
          <name>MODBUS_SLAVE</name>
          <file>
            <name>$PROJ_DIR$\..\Module\MODBUS_SLAVE\drv_src\modbus_slave_drv.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\MODBUS_SLAVE\drv_src\modbus_slave_drv.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\MODBUS_SLAVE\c_src\modbus_slave_glb_vars.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\MODBUS_SLAVE\c_src\modbus_slave_glb_vars.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\MODBUS_SLAVE\c_src\modbus_slave_idef.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\MODBUS_SLAVE\c_src\modbus_slave_init.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\MODBUS_SLAVE\c_src\modbus_slave_init.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\MODBUS_SLAVE\c_src\modbus_slave_task.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\MODBUS_SLAVE\c_src\modbus_slave_task.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\MODBUS_SLAVE\modbus_slave_udef.h</name>
          </file>
        </group>
        <group>
          <name>PFC</name>
          <file>
            <name>$PROJ_DIR$\..\Module\PFC\drv_src\pfc_drv.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\PFC\drv_src\pfc_drv.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\PFC\c_src\pfc_glb_vars.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\PFC\c_src\pfc_glb_vars.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\PFC\c_src\pfc_idef.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\PFC\c_src\pfc_init.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\PFC\c_src\pfc_init.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\PFC\c_src\pfc_task.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\PFC\c_src\pfc_task.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\PFC\pfc_udef.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Module\PFC\pfc_udef.h</name>
          </file>
        </group>
      </group>
    </group>
  </group>
  <group>
    <name>Drivers</name>
    <group>
      <name>CMSIS</name>
      <file>
        <name>$PROJ_DIR$\..\Core\Src\system_stm32f1xx.c</name>
      </file>
    </group>
    <group>
      <name>STM32F1xx_HAL_Driver</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_adc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_cortex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_flash_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_gpio_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_rcc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_rtc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_tim_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_uart.c</name>
      </file>
    </group>
  </group>
</project>


