# IAR project ECTproject.ewp, settings and files
configuration ECTproject (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100x8 ST STM32F100x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F100xB; STM32F10X_MD_VL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ../Module
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ECTproject.hex
  ILINK.IlinkOutputFile: ECTproject.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f100x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f100xb.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
    ../Core/Inc/: main.h
  group Application/User/Module/BTC
    ../Module/BTC/drv_src/: btc_drv.c btc_drv.h
    ../Module/BTC/c_src/: btc_glb_vars.c btc_glb_vars.h btc_idef.h btc_init.c btc_init.h btc_task.c btc_task.h
    ../Module/BTC/: btc_udef.h
  group Application/User/Module/CRC
    ../Module/CRC/drv_src/: crc_drv.c crc_drv.h
    ../Module/CRC/c_src/: crc_glb_vars.c crc_glb_vars.h crc_idef.h crc_init.c crc_init.h crc_task.c crc_task.h
    ../Module/CRC/: crc_udef.h
  group Application/User/Module/FK
    ../Module/FK/: fk_adc_udef.h fk_dac_udef.h fk_dma_udef.h fk_flash_udef.h fk_gpio_udef.h fk_i2c_udef.h fk_nvic_udef.h fk_power_udef.h fk_rtc_udef.h fk_spi_udef.h fk_system_udef.h fk_timer_udef.h fk_uart_udef.h fk_udef.h fk_watch_dog_udef.h
    ../Module/FK/drv_src/: fk_drv.c fk_drv.h
    ../Module/FK/c_src/: fk_glb_vars.c fk_glb_vars.h fk_idef.h fk_init.c fk_init.h fk_task.c fk_task.h
  group Application/User/Module/HBTC
    ../Module/HBTC/drv_src/: hbtc_drv.c hbtc_drv.h
    ../Module/HBTC/c_src/: hbtc_glb_vars.c hbtc_glb_vars.h hbtc_idef.h hbtc_init.c hbtc_init.h hbtc_task.c hbtc_task.h
    ../Module/HBTC/: hbtc_udef.h
  group Application/User/Module/MODBUS_SLAVE
    ../Module/MODBUS_SLAVE/drv_src/: modbus_slave_drv.c modbus_slave_drv.h
    ../Module/MODBUS_SLAVE/c_src/: modbus_slave_glb_vars.c modbus_slave_glb_vars.h modbus_slave_idef.h modbus_slave_init.c modbus_slave_init.h modbus_slave_task.c modbus_slave_task.h
    ../Module/MODBUS_SLAVE/: modbus_slave_udef.h
  group Application/User/Module/PFC
    ../Module/PFC/drv_src/: pfc_drv.c pfc_drv.h
    ../Module/PFC/c_src/: pfc_glb_vars.c pfc_glb_vars.h pfc_idef.h pfc_init.c pfc_init.h pfc_task.c pfc_task.h
    ../Module/PFC/: pfc_udef.c pfc_udef.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
